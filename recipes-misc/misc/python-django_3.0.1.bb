
SUMMARY = "A high-level Python Web framework"
HOMEPAGE = "http://www.djangoproject.com/"
LICENSE = "BSD-3-Clause"


require python-django.inc  

SRC_URI[md5sum] = "12f434ed7ccd6ee57be6f05a45e20e97"
SRC_URI[sha256sum] = "315b11ea265dd15348d47f2cbb044ef71da2018f6e582fed875c889758e6f844"

RDEPENDS_${PN} += " \
"

